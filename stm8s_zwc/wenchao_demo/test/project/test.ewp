# IAR project test.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: D:\my work\stm8\stm8s_zwc\STM8S_StdPeriph_conf; D:\my work\stm8\stm8s_zwc\STM8S_StdPeriph_Driver\inc; D:\my work\stm8\stm8s_zwc\wenchao_demo\test\user; D:\my work\stm8\stm8s_zwc\wenchao_lib
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: test.srec
  ILINK.IlinkOutputFile: test.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group STM8S_StdPeriph_conf
    ../../../STM8S_StdPeriph_conf/: stm8s_it.c
  group STM8S_StdPeriph_Driver
    ../../../STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c stm8s_wwdg.c
  group user
    ../user/: bsp.c main.c
